# Autodesk Inventor assembly: 21.1044 HINGE 19 S
## iProperties
Created: 2011-05
Part Number: 21.1044 HINGE 19 S
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
